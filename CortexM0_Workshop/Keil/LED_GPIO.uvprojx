# Keil uVision project LED_GPIO.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: LED_GPIO
  AfterMake: fromelf -cvf .\Objects\LED_GPIO.axf --vhx --32x1 -o convertedCode.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../LAB RESOURCES_LED _GPIO/LAB RESOURCES_LED _GPIO/ASSEMBLY_CODE/: ARM_gpio.s
